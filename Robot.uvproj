# Keil uVision project Robot.uvproj, settings and files
target Robot (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Robot +hex
  c flags: Optim=1
  c include: .\Header\Additional_Include;.\Header\CMSIS_Include;.\Header\Peripheral_Include;.\Header\Source_Include;.\Header\ST_Include;.\Header\Ultility_Include;.\Header\TM_Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./Startup/: startup_stm32f4xx.s
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c
  group Source
    ./Source/: led.c main.c string_manipulator.c uart.c system.c motor.c gpio.c robot.c button.c
  group Peripheral
    ./Peripheral/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Ultility
    ./Ultility/: stm32f4_discovery.c
  group PWM
    ./TM_PWM/: tm_stm32f4_gpio.c tm_stm32f4_pwm.c tm_stm32f4_timer_properties.c
